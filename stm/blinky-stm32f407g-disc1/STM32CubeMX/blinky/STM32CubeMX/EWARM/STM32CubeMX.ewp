# IAR project STM32CubeMX.ewp, settings and files
configuration STM32CubeMX (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F407xx
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include; ../../../../deps/stk/include; ../../../../src; ../../../../deps/build/example/driver
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: STM32CubeMX.hex
  ILINK.IlinkOutputFile: STM32CubeMX.out
  ILINK.IlinkIcfFile: stm32f407xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCOptLevel: 0
  group Application/EWARM
    ./: startup_stm32f407xx.s
  group Application/STK
    ../../../../deps/stk/include/: stk.h stk_arch.h stk_common.h stk_defs.h stk_helper.h stk_linked_list.h
  group Application/STK/arch
    ../../../../deps/stk/src/arch/arm/cortex-m/: stk_arch_arm-cortex-m.cpp
    ../../../../deps/stk/include/arch/arm/cortex-m/: stk_arch_arm-cortex-m.h
    ../../../../deps/stk/include/arch/: stk_arch_common.h
  group Application/STK/memory
    ../../../../deps/stk/include/memory/: stk_memory.h stk_memory_allocator.h stk_memory_blockpool.h
  group Application/STK/strategy
    ../../../../deps/stk/include/strategy/: stk_strategy_edf.h stk_strategy_fpriority.h stk_strategy_monotonic.h stk_strategy_rrobin.h stk_strategy_swrrobin.h
  group Application/STK/sync
    ../../../../deps/stk/include/sync/: stk_sync.h stk_sync_cs.h stk_sync_cv.h stk_sync_event.h stk_sync_eventflags.h stk_sync_msgqueue.h stk_sync_mutex.h stk_sync_pipe.h stk_sync_rwmutex.h stk_sync_semaphore.h stk_sync_spinlock.h
  group Application/STK/time
    ../../../../deps/stk/include/time/: stk_time.h stk_time_timer.h stk_time_util.h
  group Application/User
    ../Src/: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c
  group Application/User/Example
    ../../../../src/build/example/blinky/: example.cpp example.h
    ../../../../src/: stk_config.h
  group Application/User/Example/Driver
    ../../../../deps/build/example/driver/: c_wrapper.cpp cpu.h led.h
  group Application/User/Example/Driver/stm32f4xx
    ../../../../deps/build/example/driver/stm32f4xx/: led.cpp
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c
